# Keil uVision project LCD12864.uvprojx, settings and files
target LCD12864 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SC32F5832 SILAN
  pack: Keil.SC32F5832_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCD12864 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LCD12864;..\HARDWARE\ST_delay
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/ST_delay/: delay.c
    ../HARDWARE/LCD12864/: LCD12864.c
  group FWLIB
    ../FWLib/src/: ADC.c CLK.c CMP.c DevInit.c DMA.c ERU.c ETIMER.c GPIO.c IAP.c IRQ.c ISR.c OPA.c PWM.c Uart0.c Uart1.c WDT.c
  group CORE
    ../CORE/: startup_SC32F5832.s system_SC32F5832.c
software components: CMSIS:CORE 5.3.0
