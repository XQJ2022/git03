# Keil uVision project M01218.uvprojx, settings and files
target M01218 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SC32F5832 SILAN
  pack: Keil.SC32F5832_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: M01218 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\FWLib\inc;..\HARDWARE\ST_delay;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\keyboard4x4
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/ST_delay/: delay.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/BEEP/: BEEP.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/keyboard4x4/: keyboard4x4.c
  group CORE
    ../CORE/: startup_SC32F5832.s system_SC32F5832.c
  group FWLIB
    ../FWLib/src/: ADC.c CLK.c CMP.c DevInit.c DMA.c ERU.c ETIMER.c GPIO.c IAP.c IRQ.c ISR.c OPA.c PWM.c Uart0.c Uart1.c WDT.c
software components: CMSIS:CORE 5.3.0
